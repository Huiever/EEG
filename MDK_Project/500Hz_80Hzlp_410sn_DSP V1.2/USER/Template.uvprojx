# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart6;..\USER;..\FWLIB\inc;..\HARDWARE\IWDG;..\HARDWARE\EXTI;..\HARDWARE\SPI;..\HARDWARE\ADS129x;..\HARDWARE\TIMER;..\HARDWARE\AD5754R;..\DSP_LIB;..\DSP_LIB\Include;..\IIR;..\HARDWARE\LVBO
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_rtc.c stm32f4xx_dma.c stm32f4xx_pwr.c stm32f4xx_iwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart6/: usart6.c
  group HARDWARE
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/ADS129x/: ads129x.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/AD5754R/: ad5754r.c
    ../HARDWARE/LVBO/: lvbo.c
  group DSP_LIB
    ../DSP_LIB/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 5.3.0
